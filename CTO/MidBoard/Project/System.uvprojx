# Keil uVision project System.uvprojx, settings and files
target System (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: System +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, USE_STM3210E_EVAL
  c include: ..\CM3\CoreSupport;..\CM3\DeviceSupport\ST\STM32F10x;..\Hardware;..\Libraries\inc;..\Libraries\src;..\Modbus;..\Pid;..\Protocol;..\User;..\Config
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group CM3
    ../CM3/CoreSupport/: core_cm3.c
    ../CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Libraries
    ../Libraries/src/: misc.c stm32f10x_crc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_iwdg.c
  group Hardware
    ../Hardware/: AD.c DAC8554.c Dio.c io_spi.c MuxCfg.c myiic.c Pwm.c W25Q16.c
  group Config
    ../Config/: timer.c usart.c delay.c Globle.c
  group Protocol
    ../Protocol/: touchscreen.c protocol.c
  group Modbus
    ../Modbus/: modbus.c modbusNew.c
  group Pid
    ../Pid/: pid.c
  group User
    ../User/: main.c stm32f10x_it.c
  group Startup
    ../Startup/: startup_stm32f10x_hd.s
