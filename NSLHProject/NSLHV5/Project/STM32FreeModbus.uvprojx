# Keil uVision project STM32FreeModbus.uvprojx, settings and files
target STM32FreeModbus (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32FreeModbus +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\CM3\CoreSupport;..\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\inc;..\Libraries\src;..\User;..\Hardware;..\Config;..\FreeModbus\Modbus;..\FreeModbus\Port;..\Protocol
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CM3
    ../CM3/CoreSupport/: core_cm3.c
    ../CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Libraries
    ../Libraries/src/: misc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group Startup
    ../startup/: startup_stm32f10x_hd.s
  group Hardware
    ../Hardware/: adc.c dac.c digital_io.c rtd.c timer.c usart.c
  group Config
    ../Config/: globe.c systick_timer.c
  group Port
    ../FreeModbus/Port/: portevent.c portserial.c porttimer.c mbascii.c
  group Function
    ../FreeModbus/Functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
  group Modbus
    ../FreeModbus/Modbus/: mb.c mbcrc.c mbrtu.c
  group Protocol
    ../Protocol/: touchscreen.c
  group User
    ../User/: main.c logic.c stm32_it.c
  group Doc
    ../Doc/: readme.txt
