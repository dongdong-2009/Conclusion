# Keil uVision project System.uvprojx, settings and files
target SystemTest (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: System +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\CM3\CoreSupport;..\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\inc;..\Libraries\src;..\protocol;..\hardware;..\user;..\algorithm
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CM3
    ../CM3/CoreSupport/: core_cm3.c
    ../CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Libraries
    ../Libraries/src/: misc.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_iwdg.c stm32f10x_wwdg.c
  group Hardware
    ../hardware/: adc.c dac.c digital_io.c globe.c rtd.c systick_timer.c timer.c usart.c flash.c wwdg.c
  group Protocol
    ../protocol/: protocol.c runtimedata.c touchscreen.c
  group Algorithm
    ../algorithm/: pid.c algorithm.c
  group User
    ../user/: logic.c main.c stm32_it.c modbus.c
  group Startup
    ../startup/: startup_stm32f10x_hd.s
