# Keil uVision project LDDS_RE.uvprojx, settings and files
target LDDS_RE (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LDDS_RE +hex
  c flags: Optim=1
  c include: ..\CM3\CoreSupport;..\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\inc;..\Libraries\src;..\startup;..\USER
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ../USER/: main.c stm32f10_dac.c stm32f10_gpio.c stm32f10_timer.c stm32f10_usart.c stm32f10x_it.c analogin.c heatpump_ctrl.c logic.c
  group LIB
    ../Libraries/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c
  group CM3
    ../CM3/CoreSupport/: core_cm3.c
    ../CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group ST
    ../startup/: startup_stm32f10x_hd.s
software components: CMSIS:CORE 5.0.2
