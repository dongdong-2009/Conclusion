# IAR project 4xADS1220_FR4133_PT100_PT1K_V2_EW62.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlsfn.h
  General.OGChipSelectMenu: MSP430FR4133 MSP430FR4133
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: $TOOLKIT_DIR$\inc; $TOOLKIT_DIR$\inc\clib; $TOOLKIT_DIR$\inc\dlib\c; ..\bsp; ..\middleware
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430fr4133.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group application
    ./: main.c
  group BSP
    ../bsp/: ADS1220.c bsp_board.c bsp_leds.c delay.c delay.h eeprom.c gpio.c io_spi.c RTD_Math_1.c spi_slave.c
  group middleware
    ../middleware/: utilities.c
