<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>MSP430</name>
    </toolchain>
    <debug>1</debug>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>MSP430</name>
    </toolchain>
    <debug>0</debug>
  </configuration>
  <group>
    <name>application</name>
    <file>
      <name>$PROJ_DIR$\main.c</name>
    </file>
  </group>
  <group>
    <name>BSP</name>
    <file>
      <name>$PROJ_DIR$\..\bsp\ADS1220.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\bsp\bsp_board.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\bsp\bsp_leds.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\bsp\delay.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\bsp\delay.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\bsp\eeprom.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\bsp\gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\bsp\io_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\bsp\RTD_Math_1.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\bsp\spi_slave.c</name>
    </file>
  </group>
  <group>
    <name>middleware</name>
    <file>
      <name>$PROJ_DIR$\..\middleware\utilities.c</name>
    </file>
  </group>
</project>


