<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\4xADS1220_FR4133_PT100_PT1K_V2_EW62.ewp</path>
  </project>
  <batchBuild/>
</workspace>


