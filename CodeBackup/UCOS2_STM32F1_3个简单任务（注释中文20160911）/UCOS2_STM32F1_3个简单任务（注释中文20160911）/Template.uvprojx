# Keil uVision project Template.uvprojx, settings and files
target Project_Name (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ExecutableFile +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: .\App;.\Bsp;.\Libraries\CMSIS\CoreSupport;.\Libraries\CMSIS\DeviceSupport;.\Libraries\CMSIS\DeviceSupport\startup;.\Libraries\STM32F10x_StdPeriph_Driver\inc;.\Libraries\STM32F10x_StdPeriph_Driver\src;.\uCOS-II\Ports;.\uCOS-II\Source
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup Code
    ./Libraries/CMSIS/DeviceSupport/startup/: startup_stm32f10x_hd.s
  group STM32F10x_StdPeriph_Driver
    ./Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c
  group CMSIS
    ./Libraries/CMSIS/DeviceSupport/: system_stm32f10x.c
  group uC/OS-II Source
    ./uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uC/OS-II Ports
    ./uCOS-II/Ports/: os_cpu_a.asm os_cpu_c.c
  group Bsp
    ./Bsp/: bsp.c
  group App
    ./App/: main.c app_cfg.c app_task.c stm32f10x_it.c
  group Doc
    ./Doc/: ReadMe.txt
