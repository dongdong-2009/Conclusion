# Keil uVision project ProtocolTest.uvprojx, settings and files
target NSLH_V2 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ProtocolTest +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\CM3\CoreSupport;..\CM3\DeviceSupport\ST\STM32F10x;..\hardware;..\Libraries\inc;..\Libraries\src;..\protocol;..\user;..\algorithm
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CM3
    ../CM3/CoreSupport/: core_cm3.c
    ../CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Libraries
    ../Libraries/src/: misc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group Hardware
    ../hardware/: adc.c dac.c digital_io.c rtd.c systick_timer.c timer.c usart.c
  group protocol
    ../protocol/: protocol.c runtimedata.c touchscreen.c
  group startup
    ../startup/: startup_stm32f10x_hd.s
  group user
    ../user/: main.c stm32_it.c logic.c
  group algorithm
    ../algorithm/: algorithm.c pid.c
