# IAR project Backup (2) of DT7_AFE253_V00.ewp, settings and files
configuration Debug (MSP430, debug)
  General.OGChipSelectMenu: MSP430AFE253 MSP430AFE253
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\dlib\c; ; zlggui\lcddrv; zlggui\zlggui
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 2
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnk430afe253.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  ICC430.CCDefines: NDEBUG
  ICC430.newCCIncludePaths: 
  ICC430.CCOptStrategy: 0
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430AFE253.xcl
  group Source file
    User/: _main.c sd24.C utilities.c
