<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\DT7_AFE253_V00.ewp</path>
  </project>
  <batchBuild/>
</workspace>


