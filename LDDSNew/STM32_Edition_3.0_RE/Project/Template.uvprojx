# Keil uVision project Template.uvprojx, settings and files
target DEH (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\Libraries\CMSIS\startup;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\CMSIS;..\User;..\Libraries\STM32F10x_StdPeriph_Driver\src;..\User\InterfaceLib;..\User\LinkListLib;..\User\Algorithm;..\User\LddsSp
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd_revised.s startup_stm32f10x_hd.s
  group CMSIS
    ../Libraries/CMSIS/: _core_cm3.h core_cm3.c stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group DriverLib
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c misc.c
  group Doc
    ../: read me.txt
  group User
    ../User/: main.c subroutine.c protocol.c stm32f10x_it.c
  group InterfaceLib
    ../User/InterfaceLib/: adc.c dac.c digital_io.c pid.c rtd.c systick_timer.c timer.c usart.c runtimedata.c
  group Algorithm
    ../User/Algorithm/: lookuptable.c diyfunc.c
  group HeadFiles
    ../User/InterfaceLib/: adc.h dac.h digital_io.h rtd.h systick_timer.h timer.h usart.h runtimedata.h pid.h
    ../User/Algorithm/: lookuptable.h
    ../User/LddsSp/: LddsSp.h Lddsmain.h extvart.h
  group LddsSp
    ../User/LddsSp/: LddsSp.c
software components: CMSIS:CORE 5.0.2
