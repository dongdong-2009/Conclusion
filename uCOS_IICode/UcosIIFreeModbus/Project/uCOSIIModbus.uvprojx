# Keil uVision project uCOSIIModbus.uvprojx, settings and files
target UcosIIModbus (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: uCOSIIModbus
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\App;..\Bsp;..\FreeModbus\Functions;..\FreeModbus\Modbus;..\FreeModbus\Port;..\Libraries\CMSIS\CoreSupport;..\Libraries\CMSIS\DeviceSupport;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\Libraries\STM32F10x_StdPeriph_Driver\src;..\uCOSII\Ports;..\uCOSII\Source
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Startup
    ../Libraries/CMSIS/DeviceSupport/startup/: startup_stm32f10x_hd.s
  group CM3
    ../Libraries/CMSIS/CoreSupport/: core_cm3.c
    ../Libraries/CMSIS/DeviceSupport/: system_stm32f10x.c
  group Libraries
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group Bsp
    ../Bsp/: bsp.c delay.c
  group App
    ../App/: app_cfg.c app_task.c main.c stm32f10x_it.c
  group FM-Modbus
    ../FreeModbus/Modbus/: mb.c mbcrc.c mbrtu.c
  group FM-Function
    ../FreeModbus/Functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
  group FM-Port
    ../FreeModbus/Port/: mbascii.c portevent.c portserial.c porttimer.c
  group uCOSII-Source
    ../uCOSII/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uCOSII-Ports
    ../uCOSII/Ports/: os_cpu_c.c os_cpu_a.asm
