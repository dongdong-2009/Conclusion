# Keil uVision project ModbusMaster.uvprojx, settings and files
target ModbusMaster (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ModbusMaster
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\CM3\CoreSupport;..\CM3\DeviceSupport\ST\STM32F10x;..\Libraries\inc;..\Libraries\src;..\Master;..\User;..\Hardware
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CM3
    ../CM3/CoreSupport/: core_cm3.c
    ../CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Startup
    ../Startup/: startup_stm32f10x_hd.s
  group Libraries
    ../Libraries/src/: misc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group Master
    ../Master/: master.c ringbuffer.c trans_recieve_buff_control.c Modbus_m.c
  group Hardware
    ../Hardware/: delay.c timer.c usart.c
  group User
    ../User/: main.c stm32_it.c
