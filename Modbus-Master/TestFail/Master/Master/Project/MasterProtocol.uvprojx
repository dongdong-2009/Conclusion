# Keil uVision project MasterProtocol.uvprojx, settings and files
target MasterProtocol (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MasterProtocol +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\CM3;..\Hardware;..\Libraries\inc;..\Libraries\src;..\Modbus\app;..\Modbus\config;..\Modbus\core;..\Modbus\port;..\User
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CM3
    ../CM3/: core_cm3.c system_stm32f10x.c
  group Startup
    ../Startup/: startup_stm32f10x_hd.s
  group Modbus
    ../Modbus/app/: mb_app.c
    ../Modbus/core/: mb_core.c mb_crc.c
    ../Modbus/port/: mb_port.c
  group Hardware
    ../Hardware/: led.c timer.c usart.c
  group Libraries
    ../Libraries/src/: misc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_sdio.c stm32f10x_tim.c stm32f10x_usart.c
  group User
    ../User/: main.c
