# Keil uVision project WifiCtrl.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: nuedc +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,HSE_VALUE=8000000
  c include: .\src\Libraries\CMSIS\CM3\CoreSupport;.\src\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\src\Libraries\STM32F10x_StdPeriph_Driver\inc;.\src\Bsp;.\src\MidLayer;.\src\AppLayer\CLI;.\src\AppLayer\WifiComm;.\src;.\src\AppLayer;.\modbus
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Startup
    ./src/Startup/: startup_stm32f10x_hd.s
  group Libraries
    ./src/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    ./src/Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./src/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Bsp
    ./src/Bsp/: bsp_systimer.c bsp_led.c bsp_usart.c io.c iic.c oled.c bsp_adc.c bsp_pwm.c
  group MidLayer
    ./src/MidLayer/: encode.c esp8266.c modbus_tcp.c param.c D6F_PH.c
  group AppLayer
    ./src/AppLayer/WifiComm/: uart_wifi.c wifi_server.c modbus_app.c
    ./src/AppLayer/: servo.c CO2.c diff_pressure.c display.c damper.c
  group modbus
    ./modbus/: modbus.c timer.c usart.c
  group Main
    ./src/: main.c stm32f10x_it.c
software components: CMSIS:CORE 5.0.2
